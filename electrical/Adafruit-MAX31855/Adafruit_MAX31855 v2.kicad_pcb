# Repository uwo-fast/desktop-sheet-press

File README.md:

# Open Source Scientific Sheet Press: General Overview

This repository contains the design assets for the publication [Open-source cold and hot scientific sheet press for investigating polymer-based material properties](https://doi.org/10.1016/j.ohx.2024.e00566), which details the development of an adaptable, open-source platform for polymer sheet pressing.".

## Description

The Open Source Scientific Sheet Press is a mechanical device engineered for converting plastic waste into flat sheets of recycled plastic. Drawing inspiration from existing models like Precious Plastics, this platform is designed with adaptability, flexibility, and sustainability as core principles. This repository contains the main resources for the design of the physical press and it's manufacturing.

## Key Features

1. **Adaptability**: Engineered to work with a diverse range of plastic materials.
2. **Scalability**: Modular design allows for easy scaling to meet various production needs.
3. **Flexibility**: Utilizes open-source and off-the-shelf components, with comprehensive documentation and multiple system topologies for customization.

## General Applications

1. **Material Recycling**: Transforms plastic waste into reusable sheets.
2. **Product Manufacturing**: Ideal for the production of flat plastic components across various applications.
3. **Research and Development**: Serves as a testbed for material properties and novel production methods.

## Future Directions

1. **5x5' Canadian Standardized Sheet Press**: This version will meet industrial standards within the province of Ontario.
2. **Expanding System Topologies**: Work is ongoing to offer more system variations based on desired specifications and features.
3. **Vacuum Forming Integration**: Plans to incorporate vacuum forming capabilities, expanding the range of products that can be manufactured from the recycled plastic sheets.
4. **Automation and Industry 4.0**: Future iterations will focus on integrating smart technologies for autonomous operation, real-time data analytics, and IoT capabilities.
5. **Comprehensive Sourcing**: Plans to provide sourcing information tailored to various locales, considering regional regulations, standards, and availability.
6. **Reengineering High-Cost Components**: Long-term goal to redesign non-open-source and expensive components to meet required standards and certifications.

## Repository Structure

This repository will include multiple iterations and variations of the sheet press, acting as a living document for continuous development and enhancements.

For detailed documentation, consult the respective folders and files within this repository.

## About the FAST Research Group

The Free Appropriate Sustainable Technology (FAST) research group, led by Professor Joshua Pearce, is based at Western University and focuses on driving sustainability innovations. The group works on a myriad of projects ranging from solar photovoltaic technology to alternative food to open-source hardware to distributed recycling and additive manufacturing (DRAM).

This Open Source Sheet Press project is an initiative led by the FAST group, aligning with our broader goals of sustainable development and open-source technology. We are focused on developing solutions that not only contribute to recycling and sustainable manufacturing but also push the boundaries of what's possible through continuous research and innovation.

For more information on the FAST group, please visit [FAST on Appropedia](https://www.appropedia.org/FAST).

## KiCad design electrical/Adafruit-MAX31855/Adafruit_MAX31855 v2.kicad_pcb

File electrical/README.md:

# Electrical

## Attribution

https://github.com/adafruit/MicroSD-breakout-board

https://github.com/botbotty/Nano_KiCAD

https://github.com/adafruit/Adafruit-MAX31855-breakout-board

Board: 16 copper layers, 20.3 x 22.9 mm, 18 parts (1 on the bottom side), 12 nets.

Parts:
C1, C2: 10uF; C0805K
C3: 0.01µF; _0805
D1: 1n4148; SOD-323F
D2: 1N4148; SOD-323F
FB1, FB2: Ferrite; _0805
IC1: MAX31855; SO08
IC2: LP298XS; SOT23-5L
J1: 1X2-3.5MM
JP1: Breakout; 1X06_ROUND_76
R1, R2: 10K; R0805
U$1, U$2: FIDUCIAL; FIDUCIAL_1MM
U$4, U$5: MOUNTINGHOLE2.0; MOUNTINGHOLE_2.0_PLATED
U$6: ADAFRUIT_3.5MM

Connections:
+3V3: C1.1, C2.1, IC1.4, IC2.5, JP1.2, R1.1, R2.1
+5V: IC2.1, IC2.3, JP1.1
CS: D2.A, IC1.6, R2.2
DO: IC1.7, JP1.4
GND: C1.2, C2.2, IC1.1, IC2.2, JP1.3
unnamed: FB1.1, J1.2
unnamed: D2.C, JP1.5
unnamed: D1.C, JP1.6
unnamed: C3.1, FB1.2, IC1.2
unnamed: FB2.1, J1.1
unnamed: C3.2, FB2.2, IC1.3
SCK: D1.A, IC1.5, R1.2

## KiCad design electrical/Adafruit-MicroSD+/microsd.kicad_pcb

Board: 16 copper layers, 31.8 x 25.4 mm, 14 parts (0 on the bottom side), 13 nets.

Parts:
@HOLE0, @HOLE1, @HOLE2, @HOLE3: (no value)
ACT0: RED; CHIP-LED0805
C1: 10uF/10V; A_3216-18R
C2: 0.1uF; C0805K
IC1: 4050D; SO16
IC2: LP298XS; SOT23-5L
JP1: 1X08-BIG
R1: 1K; R0805
U$1, U$2: FIDUCIAL; FIDUCIAL_1MM
X1: MICROSD

Connections:
+3V3: C1.+, IC1.1, IC2.5, JP1.2, X1.4
CD: JP1.8, X1.CD1
CLK: IC1.3, IC1.9, JP1.4
CS: IC1.7, JP1.7
DI: IC1.5, JP1.6
DO: JP1.5, X1.7
GND: C1.-, C2.2, IC1.8, IC1.11, IC1.14, IC2.2, JP1.3, X1.6, X1.MT1, X1.MT2
unnamed: ACT0.A, IC1.10
unnamed: IC1.2, X1.5
unnamed: IC1.6, R1.1, X1.2
unnamed: ACT0.C, R1.2
unnamed: IC1.4, X1.3
VCC: C2.1, IC2.1, IC2.3, JP1.1

## KiCad design electrical/Nano_KiCAD-master/NanoV3.3.kicad_pcb

Board: 2 copper layers, 43.2 x 17.8 mm, 34 parts (20 on the bottom side), 43 nets.

Parts:
C1, C4, C6, C9: 100nF; C_0603_1608Metric
C2, C5: 4,7uF_16V; CP_EIA-3216-18_Kemet-A
C3, C7, C8: 1uF; C_0603_1608Metric
D1: SS1P3L; DO-220AA
D+0: DNP; TestPoint_Pad_D1.0mm
D-0: DNP; TestPoint_Pad_D1.0mm
F1: MFFSMF050; Fuse_0603_1608Metric
FD1, FD2, FD3, FD4: DNP; Fiducial_1mm_Mask1.5mm
IC1: FT232RL; SSOP-28_5.3x10.2mm_P0.65mm
IC2: LM1117IMPX-5.0; SOT-223
IC3: 328P-MUR; VQFN-32-1EP_5x5mm_P0.5mm_EP3.254x3.254mm
J1, J2: Conn_1x15; PinHeader_1x15_P2.54mm_Vertical
J3: Conn_Mini_USB; USB_Mini-B_Lumberg_2486_01_Horizontal
J4: Conn_2x3; PinHeader_2x3_P2.54mm_Vertical
L0: Yellow; LED_0805_2012Metric
PWR0: Green; LED_0805_2012Metric
RP1, RP2: 1K; R_CAY16-4
RX0: Red; LED_0805_2012Metric
SW1: RESET; SW_SPST_3.9x2.9mm
Silkscreen_Back: Silkscreen_Front; Silkscreen_Back
Silkscreen_Front: Silkscreen_Back; Silkscreen_Front
TX0: Green; LED_0805_2012Metric
Y1: 16MHz; Resonator_SMD_Murata_CSTxExxV-3Pin_3.0x1.1mm

Connections:
3V3: C6.2, IC1.17 (3V3OUT), J2.14
+5V: C3.1, C5.1 (+), C7.1, C8.1, D1.1 (K), IC1.4 (VCCIO), IC1.20 (VCC), IC2.2, IC2.4 (OUT), IC3.4 (VCC), IC3.6 (VCC), IC3.18 (AVCC), J2.4, J4.2, RP1.5 (2), RP1.6 (2), RX0.1, TX0.1
/A0: IC3.23 (PC0(ADC0)), J2.12
/A1: IC3.24 (PC1(ADC1)), J2.11
/A2: IC3.25 (PC2(ADC2)), J2.10
/A3: IC3.26 (PC3(ADC3)), J2.9
/A4: IC3.27 (PC4(ADC4/SDA)), J2.8
/A5: IC3.28 (PC5(ADC5/SCL)), J2.7
/A6: IC3.19 (ADC6), J2.6
/A7: IC3.22 (ADC7), J2.5
/AREF: C1.1, IC3.20 (AREF), J2.13
/D0/RX: IC3.30 (PD0(RXD)), J1.2, RP1.1
/D1/TX: IC3.31 (PD1(TXD)), J1.1, RP1.2 (1)
/D2: IC3.32 (PD2(INT0)), J1.5
/D3: IC3.1 (PD3(INT1)), J1.6
/D4: IC3.2 (PD4(XCK/T0)), J1.7
/D5: IC3.9 (PD5(T1)), J1.8
/D6: IC3.10 (PD6(AIN0)), J1.9
/D7: IC3.11 (PD7(AIN1)), J1.10
/D8: IC3.12 (PB0(ICP)), J1.11
/D9: IC3.13 (PB1(OC1A)), J1.12
/D10: IC3.14 (PB2(SS/OC1B)), J1.13
/D11/MOSI: IC3.15 (PB3(MOSI/OC2)), J1.14, J4.4
/D12/MISO: IC3.16 (PB4(MISO)), J1.15, J4.1
/D13/SCK: IC3.17 (PB5(SCK)), J2.15, J4.3, RP2.1
/RESET: C4.1, IC3.29 (PC6(/RESET)), J1.3, J2.3, J4.5, RP1.4 (1), SW1.2
/RX: IC1.1 (TXD), RP1.8 (2)
/TX: IC1.5 (RXD), RP1.7 (2)
COM: C1.2, C2.2 (-), C3.2, C5.2 (-), C6.1, C7.2, C8.2, C9.2, IC1.7 (GND1), IC1.18 (GND2), IC1.21 (GND3), IC1.25 (AGND), IC1.26 (TEST), IC2.1 (GND/ADJ), IC3.3 (GND), IC3.5 (GND), IC3.21 (AGND), IC3.33 (GND), J1.4, J2.2, J3.1 (GND), J3.6 (SH1), J3.7 (SH2), J3.8 (SH3), J3.9 (SH4), J4.6, L0.2, PWR0.2, RP2.3 (1), RP2.6 (2), SW1.1, Y1.2
unnamed: C4.2, IC1.2 (DTR#)
unnamed: D+0.X, IC1.15 (USBDP), J3.3 (D+)
unnamed: D-0.X, IC1.16 (USBDM), J3.4 (D-)
unnamed: F1.2, J3.5 (VBUS)
unnamed: IC1.22 (CBUS1), RP2.4 (1)
unnamed: IC1.23 (CBUS0), RP2.2 (1)
unnamed: IC3.7 (PB6(XTAL1/TOSC1)), Y1.1
unnamed: IC3.8 (PB7(XTAL2/TOSC2)), Y1.3
unnamed: L0.1, RP2.8 (2)
unnamed: PWR0.1, RP1.3 (1)
unnamed: RP2.5 (2), TX0.2
unnamed: RP2.7 (2), RX0.2
VIN: IC2.3 (IN), J2.1
VUSB: C2.1 (+), C9.1, D1.2 (A), F1.1

## Commit log (part)

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2023-09-30 Create .gitignore
    Initial gitignore template
2023-09-30 Delete control-software directory
    Added gitignore, will repush
2023-09-30 Delete electrical-design directory
    Added gitignore, will repush
2023-09-30 Delete mechanical-design directory
    Added gitignore, will repush
2023-09-30 added structural directory
2023-09-30 Delete mechanical-design/OSCHSSP_Mini_Enclosure_v1.1.20230928-190127.FCBak
    FCbak delete
2023-09-30 Delete mechanical-design/OSCHSSP_Mini_Assembly.20230927-000818.FCBak
    FCbak delete
2023-10-08 project set up stuff and alt builds start
2023-10-08 yet more reorganizing and refactoring
2023-10-08 README
2023-10-08 README future directions upgrade
2023-10-08 README FAST stuff
2023-10-08 README tweak
2023-10-08 README tweak final
2023-10-08 README for tp-assets markdown
2023-10-08 removed lines
2023-10-08 README for fixed assets-tp to tp-assets
2023-10-08 reorg anized freecad file structure
2023-10-09 freecad cleaning & started qelectrotech design for industrial
2023-10-13 added readme for industrial opta electrical
2023-10-13 naming fix
2023-10-14 updated auto num readme
2023-10-17 coils for qet file
2023-10-22 updated the electrical schematic opta
2023-10-24 alternative suppliers
2023-10-24 sourcing components
2023-11-01 separated industrial into own repo
2023-11-01 Update README.md for scientific specifier
2023-11-02 enabled lfs for step and stl files
2023-11-09 added flow diagram mermaid js in jupyter
2023-11-12 added algo charts
2023-11-12 Upload New File
2023-12-05 updated the core software builds and added algorithm charts
2023-12-23 check push
2024-01-26 initial commit of prudentia
2024-01-26 added snap fit geo using openscad
2024-01-28 more work on the prudentia enclosure
2024-02-14 updated enclosure and added 2 DoF attachment
2024-02-20 local push
2024-02-23 printable enclosure for paper
2024-02-24 updated steps & stl for paper
2024-02-27 updated enclosure
2024-02-27 added file for updated electrical
2024-02-27 cleaned up elec dir
2024-02-28 assembly organization for easier CAD nav
2024-02-29 updated and organized files
2024-03-01 updates for paper
2024-03-05 edits to software
2024-03-08 did some more clean up and gui
2024-03-09 finishing up header for clarity
2024-03-10 updated elec
2024-03-11 added full depth to electrical and software segmentation
2024-03-11 splitting off of archives into dedicated dev archive
2024-03-12 updates to elec
2024-03-13 updates to ui
2024-03-14 updated ui
2024-03-18 rotary action gui changes
2024-03-19 optimized ram usage using PROGMEM for lcd strings
2024-04-06 version 1.1.0 adds header var for using 1 TC, fixes to uint vars
2024-04-27 v2 of elec separating gui and improved part selection
2024-05-08 minor organizational changes for paper
2024-05-22 schematic updates
2024-07-01 thermocouple non sense
2024-07-03 split in progress
2024-07-04 initial split and archived past
2024-07-15 Added Press_Software_Flow_Diagram.drawio
2024-07-30 Generalization and clean up
2024-08-20 rewrote thermal runaway as a class and improved clarify and operational logic
2024-08-21 cleaned things up by adding getters/setters and templates
2024-08-22 added to LCD
2024-08-26 Added back elec and software as submodules to new repos
2024-08-26 added todos and info to readmes in subdirs
2024-08-27 added usage docs for gui and cmd usage and cleared redundant state commands
2024-12-02 cleaned up organization and better implemented separation of concerns and best practices of modular programming where relevant
2024-12-03 cleaned up and minimized
2024-12-03 further reduced memory footprint, even more organization, only to find out the nan was just being propagated from TC measure
2025-02-03 added info linking to onshape enclosure
2025-02-03 added back from osf
2025-02-03 organized docs and moved procurement
2025-02-04 Remove .gitattributes and LFS tracking
2025-02-04 fixed readme
2025-02-04 minor updates
2025-02-11 added a sudo mode for easier testing
2025-02-11 minor fixes
2025-02-11 fixed writeRelay function correct const mismatch
2025-02-12 added phase implementation
2025-02-26 updated src readme
2025-02-27 added notes
2025-02-27 press config update
2025-02-27 added pid interval to all
2025-05-09 some clean up and reorganizing, added limiting and adaptive pid
2025-05-09 fixed some bugs

Notices in the files:
electrical/Adafruit-MicroSD+/microsd.kicad_pcb:
CC BY-SA

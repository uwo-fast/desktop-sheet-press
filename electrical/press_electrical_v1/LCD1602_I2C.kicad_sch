File: electrical/press_electrical_v1/LCD1602_I2C.kicad_sch (KiCad schematic)
At the start: 17 parts, among them Q1 S8050, U7 PCF8574

Commit message: local push
Parts:
- renumbered U7 to U3
